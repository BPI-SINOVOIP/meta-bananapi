COMPATIBLE_MACHINE:append:bananapi-ai2n = "|bananapi-ai2n"
