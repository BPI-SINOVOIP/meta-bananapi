FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:bananapi-ai2n = " \
	file://0001-add-bananapi-ai2n-board.patch"
